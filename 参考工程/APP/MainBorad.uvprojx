# Keil uVision project MainBorad.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F425RE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.4.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MainBorad +hex
  AfterMake: fromelf --bin --output .\Objects\MainBorad.bin .\Objects\MainBorad.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F425
  c include: .\FreeRTOS_Core;.\FreeRTOS_Port;.\Config;.\Core\Inc;.\Core\Src;.\GD32_Drivers\Inc;.\GD32F4xx_Firmware_Library_V3.3.1\GD32F4xx_Firmware_Library\Firmware\GD32F4xx_standard_peripheral\Include;.\GD32F4xx_Firmware_Library_V3.3.1\GD32F4xx_Firmware_Library\Firmware\CMSIS;.\GD32F4xx_Firmware_Library_V3.3.1\GD32F4xx_Firmware_Library\Firmware\CMSIS\GD\GD32F4xx\Include;.\FatFs\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group GD32_Device
    ./GD32F4xx_Firmware_Library_V3.3.1/GD32F4xx_Firmware_Library/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f405_425.s
    ./GD32F4xx_Firmware_Library_V3.3.1/GD32F4xx_Firmware_Library/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group FreeRTOS_Core
    ./FreeRTOS_Core/: tasks.c queue.c list.c timers.c event_groups.c
  group FreeRTOS_Port
    ./FreeRTOS_Port/: port.c
  group FreeRTOS_Heap
    ./FreeRTOS_MemMang/: heap_4.c
  group Application
    ./Core/Src/: main.c gd32f4xx_it.c systick.c light_sensor.c pcf8563.c host_comm.c modbus_rtu.c gimbal_control.c optical_tracking.c flash_config.c gd25q16_flash.c data_hub.c gps_nmea.c sun_position.c rs485_hal.c sd_logger.c sdcard.c sun_position_psa.c sun_position_port.c app_watchdog.c
  group FatFs
    ./FatFs/Third_Party/fat_fs/src/: ff.c ffunicode.c diskio.c fattime.c
  group GD32_Drivers
    ./GD32_Drivers/Src/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_dma.c gd32f4xx_timer.c gd32f4xx_fmc.c gd32f4xx_crc.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_i2c.c gd32f4xx_spi.c gd32f4xx_sdio.c gd32f4xx_pmu.c
    ./GD32F4xx_Firmware_Library_V3.3.1/GD32F4xx_Firmware_Library/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_fwdgt.c
