# Keil uVision project APP.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F425RE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.4.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Core\Inc;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\Include;.\Drivers\GD32F4xx_Peripherals\Include;.\FatFs\Inc;.\Config;.\FreeRTOS_Core;.\FreeRTOS_Port
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./Core/Src/: main.c gd32f4xx_it.c systick.c sdcard.c iap_update.c flash_driver.c
  group CMSIS
    ./Drivers/CMSIS/Device/Source/: system_gd32f4xx.c
  group Startup
    ./Startup/: startup_gd32f405_425.s
  group GD32F4xx_Peripherals
    ./Drivers/GD32F4xx_Peripherals/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_spi.c gd32f4xx_i2c.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_fmc.c gd32f4xx_pmu.c gd32f4xx_misc.c gd32f4xx_exti.c gd32f4xx_sdio.c gd32f4xx_syscfg.c gd32f4xx_fwdgt.c
  group FatFs
    ./FatFs/Src/: ff.c diskio.c ffunicode.c ffsystem.c
