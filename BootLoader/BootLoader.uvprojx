# Keil uVision project BootLoader.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F425RE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.4.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  AfterMake: fromelf --bin --output .\Objects\BootLoader.bin .\Objects\BootLoader.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F425
  c include: .\\Inc;.\\Drivers\\CMSIS\\Include;.\\Drivers\\CMSIS\\Device\\Include;.\\Drivers\\GD32F4xx_Peripherals\\Include
  asm define: USE_STDPERIPH_DRIVER,GD32F425
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./Src/: bootloader_main.c systick.c gd32f4xx_it.c flash_driver.c sdcard.c diskio.c ff.c sd_iap.c delay.c debug_uart.c
  group CMSIS
    ./Drivers/CMSIS/Device/Source/: system_gd32f4xx.c
  group Peripherals
    ./Drivers/GD32F4xx_Peripherals/Source/: gd32f4xx_rcu.c gd32f4xx_gpio.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_fmc.c gd32f4xx_pmu.c gd32f4xx_sdio.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_syscfg.c
  group Startup
    ./Startup/: startup_gd32f405_425.s
